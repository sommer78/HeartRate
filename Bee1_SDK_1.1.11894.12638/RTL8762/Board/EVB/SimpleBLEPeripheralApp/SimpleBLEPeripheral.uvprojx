# Keil uVision project SimpleBLEPeripheral.uvprojx, settings and files
target SimpleBLEPeripheralApp (ARM-ADS)
  device: ARMCM0 ARM
  pack: ARM.CMSIS.4.2.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0") CLOCK(12000000) ESEL ELITTLE
  output: App +hex
  AfterMake: cmd.exe /c $J\..\bin\fromelf.exe --bin -o "@L.bin" "#L" && $J\..\bin\fromelf.exe -acd --interleave=source -o "@L.disasm" "#L"
  AfterMake: cmd.exe /c ..\..\..\..\Tool\CheckSumGen\CheckSum_Gen.exe "@L.bin\@L.bin" "@L.bin\@L.bin" & ..\..\..\..\Tool\md5\md5.exe "@L.bin\@L.bin"
  c flags: Optim=3 uC99=1 wLevel=2
  c misc: --gnu  --bss_threshold=0 --preinclude=device_name.h
  c include: ..\..\..\Include\app;..\..\..\Include\os\freertos;..\..\..\Include\IO;..\..\..\Include\modules;..\..\..\Include\profile;..\..\..\Include\platform;..\..\..\Include\platform\cmsis\cm0;..\..\..\Include\stack;..\..\..\Lib;..\..\..\Source\common\Include;..\..\..\Source\common\iodriver;..\..\..\Source\common\ble\peripheral;..\..\..\Source\common\ble\gap;..\..\..\Source\common\ble\broadcaster;..\..\..\Source\common\module;..\..\..\Source\common\profile;..\..\..\Source\common;.\;..\..\..\Source\common\ble\include;..\..\..\Source\common\ble\profile;..\..\..\Source\profile
  memory RVCT4: ROM 0x50a000 size 0x19000
  memory RVCT9: RAM 0x20005c00 size 0x400
  memory RVCT10: RAM 0x2000e000 size 0x1800
  scatter file: .\App.sct
  link misc: --diag_suppress=L6314 --no_remove --datacompressor=off
  group LIB
    ../../../Lib/: symboltable.lib
  group CMSIS
    ../../../Source/common/rtl876x/: system_rtl8762.c
    ../../../Source/common/rtl876x/arm/: arm_startup_rtl8762.s
  group BLE
    ../../../Source/common/ble/gap/: gapbondmgr.c peripheral.c
    ../../../Source/common/ble/peripheral/: SimpleBLEPeripheral.c SimpleBLEPheripheral_api.c
    ../../../Source/Common/BLE/Gap/: gap_common.c
  group Profile
    ../../../Source/common/ble/profile/: hdlmsg.c profile.c
    ../../../Source/profile/: simple_ble_service.c
  group Utility
    ../../../Source/application/SimpleBLEPeripheralApp/: application.c main.c peripheral_stack_api.c simpleBLEPeripheral_application.c
