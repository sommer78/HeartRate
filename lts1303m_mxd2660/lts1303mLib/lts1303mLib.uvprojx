# Keil uVision project lts1303mLib.uvprojx, settings and files
target HeartRate (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.13.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lts1303mLib (library)
  c flags: Optim=4 OneElfS=1 wLevel=2
  c include: ..\lts1303mLib
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group source
    ./: Lts1303m.c
