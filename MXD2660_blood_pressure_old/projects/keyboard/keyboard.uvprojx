# Keil uVision project keyboard.uvprojx, settings and files
target keyboard (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: keyboard +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/keyboard.bin  ./Objects/keyboard.axf
  AfterMake: ..\..\tools\ota\ota_crc.exe .\Objects\keyboard.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: FUNC_KEYBOARD_EN
  c misc: -D__CORTEX_M0P -D__CMSIS_RTOS -D_RTE_ --gnu
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;..\..\src\rtos\RTX\INC;..\..\src\system\common;..\..\src\system\pmu;..\..\src\system\rf_modem;..\..\src\ble;..\..\src\rtos\RTX\SRC\ARM;..\..\src\peripheral;..\..\src\profiles;..\..\src\application\common;..\..\src\application\keyboard;..\..\src\application\hci;..\..\src\application\ota;..\..\src\rtos\RTX\SRC;..\..\inc\application;..\..\inc\peripheral;..\..\inc\profile;..\..\inc\rtos;..\..\inc\system;..\..\inc\stack
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\scatterfile\keyboard.sct
  link misc: --entry=reset_handler  --keep=*_header  --keep=*_startup.o
  group Startup Code
    ../../src/common/startup/: cm0plus_startup.s sys.c
  group lib
    ../../lib/: symbol.lib peripheral_lib.lib
  group Profile
    ../../src/profiles/: battery_service.c dev_info_service.c hid_service.c scan_para_service.c
  group common
    ../../src/application/common/: utility.c debug.c
    ../../src/common/: err_debug.c
  group keyboard
    ../../src/application/keyboard/: app_hid_kbd.c app_ir.c app_kbd.c app_key_remap.c
  group Application
    ../../src/application/keyboard/: app_ble.c app_task.c app_main.c
    ../../src/application/common/: app_ota.c
