# Keil uVision project MXD2660XX.uvprojx, settings and files
target MXD2660 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: MXD2660XX +hex
  BeforeMake: cmd.exe /c del ".\Objects\symbol.lib"
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/MXD2660XX.bin  ./Objects/MXD2660XX.axf
  AfterMake: ..\..\tools\ota\ota_crc.exe .\Objects\wristband.bin\APP.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c misc: -D__CORTEX_M0P -D__CMSIS_RTOS -D_RTE_ --gnu
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;..\..\lib\lib_src\rtos\RTX\INC;..\..\lib\lib_src\system\common;..\..\lib\lib_src\system\pmu;..\..\lib\lib_src\ble;..\..\lib\lib_src\rtos\RTX\SRC\ARM;..\..\lib\lib_src\peripheral;..\..\lib\lib_src\root_src;..\..\lib\lib_src\ble\rf_modem;..\..\lib\lib_src\rtos\RTX\SRC;..\..\src\application\common;..\..\src\application\trunk;..\..\inc\application;..\..\inc\peripheral;..\..\inc\profile;..\..\inc\system;..\..\inc\stack;..\..\inc\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x18000
  memory RVCT9: RAM 0x20000000 size 0x8000
  scatter file: ..\..\scatterfile\MXD2660XX.sct
  link misc: --symdefs=symbol.lib --no_remove --keep=*_header
