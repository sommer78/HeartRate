# Keil uVision project Baidu-Nordic.uvproj, settings and files
target DVK_6310 (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: Baidu-Nordic +hex
  c flags: Optim=1 wLevel=2
  c define: NRF51 NRF51822_QFAA_CA,DEBUG_NRF_USER USE_DVK_6310  DEBUG_LOG TEST_SHOW_WALL_CLOCK
  c misc: --c99
  c include: ..\Source;..\nrf51822\Include;..\nrf51822\Include\app_common;..\nrf51822\Include\ble;..\nrf51822\Include\ble\ble_services;..\nrf51822\Include\ble\softdevice;..\Source\inc;..\Source\lib-inc
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Source
    ../Source/src/: main.c bd_battery.c bd_ble_nus.c bd_buzzer.c bd_communicate_protocol.c bd_interrupt_notify.c bd_input_event_source.c bd_led_flash.c bd_private_bond.c bd_wall_clock_timer.c bd_drv2605.c bd_hal_acc.c bd_hal_vibrate.c bd_lis3dh_driver.c bd_nrf_delay.c bd_spi_master.c bd_step_counter.c bd_twi_hw_master.c bd_sync_data.c bd_interaction.c bd_charging.c bd_crc16.c bd_square_root.c bd_level_drive_motor.c bd_factory_test.c bd_low_power_mode.c bd_switch_sleep.c bd_wdt.c bd_stack_dump_repoter.c bd_data_manager.c
  group SystemStart
    ../nrf51822/Source/templates/arm/: arm_startup_nrf51.s
    ../nrf51822/Source/templates/: system_nrf51.c
  group Service
    ../nrf51822/Source/ble/ble_services/: ble_tps.c ble_srv_common.c ble_bas.c ble_dis.c
  group Libriaries
    ../nrf51822/Source/ble/: ble_advdata.c ble_conn_params.c ble_debug_assert_handler.c ble_flash.c ble_radio_notification.c ble_stack_handler.c ble_bondmngr.c ble_error_log.c
    ../nrf51822/Source/app_common/: app_button.c app_gpiote.c app_scheduler.c app_timer.c
    ../nrf51822/Source/simple_uart/: simple_uart.c
  group AlgorithmLib
    ../Source/libs/: AlgorithmLibFornrf51.lib
target BD_PUBLIC (ARM-ADS)
  device: nRF51822_xxAA Nordic
  cpu: as above
  output: Baidu-Nordic +hex
  AfterMake: C:\Keil\ARM\ARMCC\bin\fromelf.exe .\out\BD_PUBLIC\Baidu-Nordic.axf --output .\out\BD_PUBLIC\Baidu-Nordic.bin --bin
  c flags: Optim=4 wLevel=2
  c define: NRF51 NRF51822_QFAA_CA,DEBUG_NRF_USER BD_PUBLIC
  c misc: --c99
  c include: as above
  memory RVCT4: ROM 0x14000 size 0x2b000
  memory RVCT9: RAM 0x20002000 size 0x2000
