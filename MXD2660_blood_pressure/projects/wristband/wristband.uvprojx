# Keil uVision project wristband.uvprojx, settings and files
target wristband (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: wristband +hex
  AfterMake: d:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/wristband.bin  ./Objects/wristband.axf
  AfterMake: ..\..\tools\ota\ota_crc.exe .\Objects\wristband.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: FUNC_WRISTBAND_EN
  c misc: -D__CORTEX_M0P -D__CMSIS_RTOS -D_RTE_ --gnu
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;..\..\src\application\common;..\..\src\application\keyboard;..\..\src\application\trunk;..\..\src\application\ota;..\..\inc\application;..\..\inc\peripheral;..\..\inc\profile;..\..\inc\system;..\..\inc\stack;..\..\src\application\wrsitband;..\..\src\common;..\..\inc\rtos;..\..\src\ts1303
  library: MicroLIB
  memory RVCT4: ROM 0x30000 size 0x10000
  memory RVCT9: RAM 0x20005800 size 0x2800
  scatter file: ..\..\scatterfile\wristband.sct
  link misc: --entry=reset_handler  --keep=*_header  --keep=*_startup.o --keep=*_task.o
  group Startup Code
    ../../src/common/startup/: cm0plus_startup.s sys.c
  group lib
    ../../lib/: symbol.lib peripheral_lib.lib
  group common
    ../../src/common/: calendar.c err_debug.c
    ../../src/application/common/: utility.c debug.c
  group Profile
    ../../src/profiles/: ancs_service.c wristband_service.c
  group wristband
    ../../src/application/wrsitband/: LCM_00930.c lis3dh_driver.c zx_7816.c wristband_application.c led.c
  group Application
    ../../src/application/wrsitband/: app_task.c app_ble.c app_main.c
    ../../src/application/common/: app_ota.c
  group ts1303
    ../../src/ts1303/: Lts1303m.c SimPress.c
