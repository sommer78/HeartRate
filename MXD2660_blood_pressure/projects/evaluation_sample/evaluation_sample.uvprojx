# Keil uVision project evaluation_sample.uvprojx, settings and files
target Evaluation_sample (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.0.1
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: evaluation +hex
  AfterMake: d:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin -o ./Objects/evaluation.bin  ./Objects/evaluation.axf
  AfterMake: ..\..\tools\ota\ota_crc.exe .\Objects\evaluation.bin
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: FUNC_EVALUATION_EN
  c misc: -D__CORTEX_M0P -D__CMSIS_RTOS -D_RTE_ --gnu
  c include: C:\Keil_v5\ARM\Pack\ARM\CMSIS\4.5.0\CMSIS\Include;..\..\src\application\common;..\..\src\application\keyboard;..\..\src\application\trunk;..\..\src\application\ota;..\..\inc\application;..\..\inc\peripheral;..\..\inc\profile;..\..\inc\system;..\..\inc\stack;..\..\src\application\wrsitband;..\..\src\common;..\..\inc\rtos
  library: MicroLIB
  memory RVCT4: ROM 0x28000 size 0x18000
  memory RVCT9: RAM 0x20005800 size 0x2800
  scatter file: ..\..\scatterfile\evaluation_sample.sct
  link misc: --entry=reset_handler   --keep=*_header  --keep=*_startup.o --keep=*_task.o
  group Startup Code
    ../../src/common/startup/: cm0plus_startup.s sys.c
  group lib
    ../../lib/: symbol.lib peripheral_lib.lib
  group Profile
    ../../src/profiles/: mxd_trx_service.c ancs_service.c
  group common
    ../../src/common/: calendar.c err_debug.c
    ../../src/application/common/: utility.c debug.c
  group hci_app
    ../../src/hci_app/: hci_cmd.c hci_msg_api.c hci_api.c hci_event.c
  group module
    ../../src/application/evaluation_sample/: led.c
  group Application
    ../../src/application/evaluation_sample/: app_ble.c app_main.c app_task.c
    ../../src/application/common/: app_ota.c
